# Keil uVision project template.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F011C8T7 ArteryTek
  pack: ArteryTek.AT32F011_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2400) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F011C8T7,USE_STDPERIPH_DRIVER,AT_START_F011_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm0plus\core_support;..\..\..\..\libraries\cmsis\cm0plus\device_support;..\inc;..\..\..\at32f011_board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
  group user
    ../src/: at32f011_clock.c at32f011_int.c main.c
  group bsp
    ../../../at32f011_board/: at32f011_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32f011_adc.c at32f011_crc.c at32f011_crm.c at32f011_debug.c at32f011_dma.c at32f011_ertc.c at32f011_exint.c at32f011_flash.c at32f011_gpio.c at32f011_hwdiv.c at32f011_i2c.c at32f011_misc.c at32f011_pwc.c at32f011_scfg.c at32f011_spi.c at32f011_tmr.c at32f011_usart.c at32f011_wdt.c at32f011_wwdt.c
  group cmsis
    ../../../../libraries/cmsis/cm0plus/device_support/: system_at32f011.c
    ../../../../libraries/cmsis/cm0plus/device_support/startup/mdk/: startup_at32f011.s
  group readme
    ../: readme.txt
