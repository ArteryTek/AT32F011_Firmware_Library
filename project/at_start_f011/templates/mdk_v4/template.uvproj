# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: AT32F011C8T7 ArteryTek
  output: Template +hex
  c flags: Optim=1
  c define: AT32F011C8T7,USE_STDPERIPH_DRIVER,AT_START_F011_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm0plus\core_support;..\..\..\..\libraries\cmsis\cm0plus\device_support;..\inc;..\..\..\at32f011_board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
  group user
    ../src/: at32f011_int.c at32f011_clock.c main.c
  group bsp
    ../../../at32f011_board/: at32f011_board.c
  group cmsis
    ../../../../libraries/cmsis/cm0plus/device_support/startup/mdk/: startup_at32f011.s
    ../../../../libraries/cmsis/cm0plus/device_support/: system_at32f011.c
  group firmware
    ../../../../libraries/drivers/src/: at32f011_adc.c at32f011_crc.c at32f011_crm.c at32f011_debug.c at32f011_dma.c at32f011_ertc.c at32f011_exint.c at32f011_flash.c at32f011_gpio.c at32f011_hwdiv.c at32f011_i2c.c at32f011_misc.c at32f011_pwc.c at32f011_scfg.c at32f011_spi.c at32f011_tmr.c at32f011_usart.c at32f011_wdt.c at32f011_wwdt.c
  group readme
    ../: readme.txt
