# IAR project app_led3_toggle.ewp, settings and files
configuration app_led3_toggle (ARM, debug)
  General.OGChipSelectEditMenu: AT32F011C8T7_v2 ArteryTek AT32F011C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F011C8T7; USE_STDPERIPH_DRIVER; AT_START_F011_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm0plus\core_support; ..\..\..\..\..\libraries\cmsis\cm0plus\device_support; ..\inc; ..\..\..\..\..\project\at32f011_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32F011x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../project/at32f011_board/: at32f011_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm0plus/device_support/startup/iar/: startup_at32f011.s
    ../../../../../libraries/cmsis/cm0plus/device_support/: system_at32f011.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f011_crm.c at32f011_flash.c at32f011_gpio.c at32f011_misc.c at32f011_tmr.c at32f011_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f011_clock.c at32f011_int.c iap.c main.c tmr.c usart.c
