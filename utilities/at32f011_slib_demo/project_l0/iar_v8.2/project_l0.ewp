# IAR project project_l0.ewp, settings and files
configuration project_l0 (ARM)
  General.OGChipSelectEditMenu: AT32F011C8T7_v2 ArteryTek AT32F011C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F011C8T7; USE_STDPERIPH_DRIVER; AT_START_F011_V1; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm0plus\device_support; ..\..\..\..\libraries\cmsis\cm0plus\core_support; ..\inc; ..\..\..\..\project\at32f011_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project_l0.hex
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "fir_filter_symbol.o"
  ILINK.IlinkOutputFile: project_l0.out
  ILINK.IlinkIcfFile: AT32F011x8_slib.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../project/at32f011_board/: at32f011_board.c
  group cmsis
    ../../../../libraries/cmsis/cm0plus/device_support/startup/iar/: startup_at32f011.s
    ../../../../libraries/cmsis/cm0plus/device_support/: system_at32f011.c
  group fir_filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_coefficient.c fir_filter.c
  group firmware
    ../../../../libraries/drivers/src/: at32f011_crm.c at32f011_usart.c at32f011_flash.c at32f011_gpio.c at32f011_misc.c
  group readme
    ../: readme.txt
  group user
    ../src/: arm_fir_data.c at32f011_clock.c at32f011_int.c main.c math_helper.c
