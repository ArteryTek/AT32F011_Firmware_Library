# Keil uVision project freertos_demo.uvprojx, settings and files
target freertos_demo_ac5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F011C8T7 ArteryTek
  pack: ArteryTek.AT32F011_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2400) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: freertos_demo_ac5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F011C8T7,USE_STDPERIPH_DRIVER,AT_START_F011_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f011_board;..\..\..\libraries\cmsis\cm0plus\device_support;..\..\..\libraries\cmsis\cm0plus\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
  group user
    ../src/: at32f011_clock.c at32f011_int.c main.c include_port.c
  group bsp
    ../../../project/at32f011_board/: at32f011_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f011_adc.c at32f011_crc.c at32f011_crm.c at32f011_debug.c at32f011_dma.c at32f011_ertc.c at32f011_exint.c at32f011_flash.c at32f011_gpio.c at32f011_hwdiv.c at32f011_i2c.c at32f011_misc.c at32f011_pwc.c at32f011_scfg.c at32f011_spi.c at32f011_tmr.c at32f011_usart.c at32f011_wdt.c at32f011_wwdt.c
  group cmsis
    ../../../libraries/cmsis/cm0plus/device_support/: system_at32f011.c
    ../../../libraries/cmsis/cm0plus/device_support/startup/mdk/: startup_at32f011.s
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group readme
    ../: readme.txt
target freertos_demo_ac6 (6160000::V6.16::ARMCLANG)
  device: AT32F011C8T7 ArteryTek
  pack: ArteryTek.AT32F011_DFP.2.0.0
  output: freertos_demo_ac6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F011C8T7,USE_STDPERIPH_DRIVER,AT_START_F011_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f011_board;..\..\..\libraries\cmsis\cm0plus\device_support;..\..\..\libraries\cmsis\cm0plus\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\GCC\ARM_CM0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
