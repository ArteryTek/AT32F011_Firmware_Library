# IAR project freertos_demo.ewp, settings and files
configuration freertos_demo (ARM)
  General.OGChipSelectEditMenu: AT32F011C8T7_v2 ArteryTek - AT32F011C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: AT_START_F011_V1; AT32F011C8T7
  ICCARM.CCIncludePath2: ..\..\..\libraries\drivers\inc; ..\..\..\libraries\cmsis\cm0plus\core_support; ..\..\..\libraries\cmsis\cm0plus\device_support; ..\..\..\middlewares\freertos\source\include; ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM0; ..\inc; ..\..\..\project\at32f011_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc
  OBJCOPY.OOCOutputFile: freertos_demo.hex
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../project/at32f011_board/: at32f011_board.c
  group cmsis
    ../../../libraries/cmsis/cm0plus/device_support/startup/iar/: startup_at32f011.s
    ../../../libraries/cmsis/cm0plus/device_support/: system_at32f011.c
  group firmware
    ../../../libraries/drivers/src/: at32f011_adc.c at32f011_crc.c at32f011_crm.c at32f011_debug.c at32f011_dma.c at32f011_ertc.c at32f011_exint.c at32f011_flash.c at32f011_gpio.c at32f011_hwdiv.c at32f011_i2c.c at32f011_misc.c at32f011_pwc.c at32f011_scfg.c at32f011_spi.c at32f011_tmr.c at32f011_usart.c at32f011_wdt.c at32f011_wwdt.c
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
    ../../../middlewares/freertos/source/portable/IAR/ARM_CM0/: port.c portasm.s
  group readme
    ../: readme.txt
  group user
    ../src/: at32f011_clock.c at32f011_int.c main.c
